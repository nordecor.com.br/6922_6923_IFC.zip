Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2025-09-25T17:22:48
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190327_2315(x64) - Exporter 20.0.0.377 - IU alternativa 20.0.0.377
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Sep 25 17:22:48 2025 * Host: MichellyManno * Database: C:\Users\miche\AppData\Local\Temp\5d48c136-9b22-4e4f-8299-7cd2eaa7926b\a9c7b6e6-b627-4ebb-aeae-18a27cb9220f\ifc * Database version: 5507 * Database creation date: Thu Sep 25 17:22:44 2025 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Sep 25 17:22:45 2025 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Sep 25 17:22:45 2025 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nome do projeto; Phase: Status do projeto

# IfcSite, Default
RefLatitude: -15, -52, 0, -120620; RefLongitude: -47, -55, 0, -114440; RefElevation: 0 mm
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuildingStorey: Nível:Cabeça de 8 mm, Nível 1
LongName: Nível 1; Elevation: 0 mm
Restrições(Type) - Base da elevação: Ponto base do projeto
Outros(Type) - Categoria: Níveis; Nome da família: Nível
Cotas - Cálculo da altura: 0 mm
Dados de identidade - Andar da construção: yes; Estrutural: no; Nome: Nível 1
Outros - Categoria: Níveis; Família: Nível: Cabeça de 8 mm; Família e tipo: Nível: Cabeça de 8 mm; ID de tipo: Nível: Cabeça de 8 mm; Tipo: Nível: Cabeça de 8 mm
Restrições - Elevação: 0 mm
Dados de identidade(Type) - Nome do tipo: Cabeça de 8 mm
Gráficos(Type) - Cor: 0; Espessura da linha: 1; Padrão de linha: Centro (1); Símbolo: M_Cabeça do nível - Círculo: M_Cabeça do nível - Círculo; Símbolo no final 1 padrão: no; Símbolo no final 2 padrão: yes

# IfcFlowTerminal: 6922, Spot_SKALY_6922_6923_Nordecor_IFC:6922:328278
In: Nível 1
Type - Material: Metal - Alumínio - Branco, LED, Plástico - PC - Transparente
Type - Cotas - Altura do Spot: 75 mm; Comprimento conector: 165 mm; Diâmetro do Spot: 47.4 mm
Type - Dados - Data de atualização: 25/09/2025; Versão: 1
Type - Dados de identidade - Código UniFormat_Assembly Code: D5020.20; Comentários de tipos: spot, LED, trilho de embutir, dupla seção, direcionável, iluminação focal; Contato do desenvolvedor: contato@checkbim.com.br; Contato do fabricante: comercial@nordecor.com.br; Descrição: Spot LED de embutir acabamento branco para trilho SKALY dupla ação 6W 2700K 24º; Descrição UniFormat_Assembly Description: Luminárias integradas ao edifício; Desenvolvedor: Check BIM; Fabricante: Nordecor; Garantia: 2 anos; IP: 20; Localização: Camboriú/SC - Brasil; Modelo: 6922; Nome do tipo: 6922; Nota-chave: 26 56 33.13; Número MasterFormat_MasterFormat Number: 26 56 33; Número OmniClass: 23.80.70.11.14.21; Número OmniClass_OmniClass Number: 23-27 37 13; Tipo de imagem: Imagem raster: 6922 img.png; Tipo de Luminária_Light Distribution: Distribuição Direcional / Focal; Título MasterFormat_MasterFormat Title: Spots e Luminárias de Trilho; Título OmniClass: Spots and Tracklight Specialties; Título OmniClass_OmniClass Title: Luminárias de Trilho e Spots; URL: https://nordecor.com.br/; URL do desenvolvedor: https://checkbim.com.br/; URL do produto: https://nordecor.com.br/produto/spot-led-para-trilho-skaly-7w-2-700k/
Type - Elétrico - Comentários de voltagem: DC48V - 2 Seções; Lâmpada: LED
Type - Estrutural - Peso da luminária_Luminaire weight: 0
Type - Fotométricos - Ângulo de abertura: 24 deg; Fluxo luminoso: 436 lm; IRC: 97; Potência: 6 W; Temperatura de cor: 2700 K
Type - Gráficos - Simbologia: Imagem raster: 6922.png
Type - Materiais e acabamentos - Difusor: Plástico - PC - Transparente; Spot: Metal - Alumínio - Branco
Type - Outros - Categoria: Luminárias; Branco: yes; Nome da família: Spot_SKALY_6922_6923_Nordecor_IFC; Preto: no
Type - Restrições - Elevação-padrão: 1219.2 mm
Type - Visibilidade - 2D: yes
Pset_DistributionFlowElementCommon - Reference: 6922; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Nordecor
Cotas - Área: 0.0187757 m2; Volume: 0.0000324383 m3
Dados de identidade - Marca: 1
Elétrico - Iluminação - Calcular coeficiente de utilização: no
Fase - Fase criada: Construção nova
Outros - Família: Spot_SKALY_6922_6923_Nordecor_IFC: 6922; Família e tipo: Spot_SKALY_6922_6923_Nordecor_IFC: 6922; ID de tipo: Spot_SKALY_6922_6923_Nordecor_IFC: 6922; Tipo: Spot_SKALY_6922_6923_Nordecor_IFC: 6922
Restrições - Elevação do nível: 0 mm; Hospedeiro: Nível : Nível 1; Nível: Nível: Nível 1; Nível de tabela: Nível: Nível 1
